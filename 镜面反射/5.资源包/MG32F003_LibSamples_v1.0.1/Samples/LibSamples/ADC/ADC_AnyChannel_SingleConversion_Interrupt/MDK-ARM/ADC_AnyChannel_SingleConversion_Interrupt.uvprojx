# Keil uVision project ADC_AnyChannel_SingleConversion_Interrupt.uvprojx, settings and files
target ADC_AnyChannel_SingleConversion_Interrupt (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MG32F003F4P7 Megawin
  pack: Megawin.MG32F003_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00000800) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ADC_AnyChannel_SingleConversion_Interrupt +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\ADC_AnyChannel_SingleConversion_Interrupt;..\..\..\..\..\Device\CMSIS\Core\Include;..\..\..\..\..\Device\MG32F003\MG32F003_Lib\inc;..\..\..\..\..\Device\MG32F003\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  group APP
    ../: main.c adc_anychannel_singleconversion_interrupt.c platform.c mg32f003_it.c
  group MG32_LIB
    ../../../../../Device/MG32F003/MG32F003_Lib/src/: mg32_adc.c mg32_crc.c mg32_dbg.c mg32_exti.c mg32_flash.c mg32_gpio.c mg32_i2c.c mg32_iwdg.c mg32_misc.c mg32_pwr.c mg32_rcc.c mg32_spi.c mg32_syscfg.c mg32_tim.c mg32_uid.c mg32_usart.c
  group STARTUP
    ../../../../../Device/MG32F003/Source/: system_mg32f003.c
    ../../../../../Device/MG32F003/Source/KEIL_StartAsm/: startup_mg32f003_keil.s
