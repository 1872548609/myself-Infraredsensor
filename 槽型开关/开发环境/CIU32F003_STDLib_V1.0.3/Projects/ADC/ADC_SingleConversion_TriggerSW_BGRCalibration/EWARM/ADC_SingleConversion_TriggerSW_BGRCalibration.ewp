# IAR project ADC_SingleConversion_TriggerSW_BGRCalibration.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CIU32F003F5Px HED CIU32F003F5Px
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CIU32F003
  ICCARM.CCIncludePath2: ..\Include; ..\..\..\..\Drivers\CIU32F003_Lib\Include; ..\..\..\..\Drivers\CMSIS\Core; ..\..\..\..\Drivers\CMSIS\Device
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ADC_SingleConversion_TriggerSW_BGRCalibration.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CIU32F003; NDBUG
  group BSP
    ../Source/: adc_bsp.c common.c
  group CIU32F003_Lib
    ../../../../Drivers/CIU32F003_Lib/Source/: ciu32f003_std.c ciu32f003_std_adc.c ciu32f003_std_comp.c ciu32f003_std_crc.c ciu32f003_std_exti.c ciu32f003_std_flash.c ciu32f003_std_gpio.c ciu32f003_std_i2c.c ciu32f003_std_lptim.c ciu32f003_std_pmu.c ciu32f003_std_rcc.c ciu32f003_std_spi.c ciu32f003_std_tim.c ciu32f003_std_uart.c
  group CMSIS
    ../../../../Drivers/CMSIS/Device/: system_ciu32f003.c
  group Doc
    ../: readme.txt
  group Startup
    ./: startup_ciu32f003.s
  group User
    ../Source/: main.c
