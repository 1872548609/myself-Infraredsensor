<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\ADC_Wakeup_SingleConversion_TriggerSW_Poll.ewp</path>
    </project>
    <batchBuild />
</workspace>
