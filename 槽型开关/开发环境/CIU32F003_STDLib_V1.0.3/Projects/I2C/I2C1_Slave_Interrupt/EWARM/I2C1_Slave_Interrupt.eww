<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\I2C1_Slave_Interrupt.ewp</path>
    </project>
    <batchBuild />
</workspace>
