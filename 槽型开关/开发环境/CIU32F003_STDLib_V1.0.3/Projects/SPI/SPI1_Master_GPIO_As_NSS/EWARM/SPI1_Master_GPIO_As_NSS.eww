<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\SPI1_Master_GPIO_As_NSS.ewp</path>
    </project>
    <batchBuild />
</workspace>
