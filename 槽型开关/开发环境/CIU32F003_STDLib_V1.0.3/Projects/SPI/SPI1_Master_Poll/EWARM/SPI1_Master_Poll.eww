<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\SPI1_Master_Poll.ewp</path>
    </project>
    <batchBuild />
</workspace>
