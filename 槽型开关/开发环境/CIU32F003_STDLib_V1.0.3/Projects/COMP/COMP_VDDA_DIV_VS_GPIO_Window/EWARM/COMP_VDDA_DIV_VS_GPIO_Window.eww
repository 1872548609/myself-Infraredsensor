<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\COMP_VDDA_DIV_VS_GPIO_Window.ewp</path>
    </project>
    <batchBuild />
</workspace>
