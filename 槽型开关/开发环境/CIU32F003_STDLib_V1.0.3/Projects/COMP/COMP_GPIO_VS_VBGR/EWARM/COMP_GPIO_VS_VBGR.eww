<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\COMP_GPIO_VS_VBGR.ewp</path>
    </project>
    <batchBuild />
</workspace>
