<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\PMU_Flash_NoWait_Wakeup.ewp</path>
    </project>
    <batchBuild />
</workspace>
