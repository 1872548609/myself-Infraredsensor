<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\TIM3_Hall.ewp</path>
    </project>
    <batchBuild />
</workspace>
