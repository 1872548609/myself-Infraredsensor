# Keil uVision project UM800Y.uvproj, settings and files
target demo (MCS-51)
  device: R8051XC2 CAST, Inc.
  cpu: IRAM(0-0xFF) CLOCK(24000000)  MOD517DP MDU_R515
  output: um800y +hex
  c flags: Optimize=8
  c include: ..\..\..\..\Driver\inc;..\..\..\..\Driver\src;..\..\..\..\MCU\Common;..\..\..\..\MCU\Device
  link misc: REMOVEUNUSED
  group system
    ../../../../MCU/Device/: STARTUP.A51 system_um800y.c
  group common
    ../source/: main.c
    ../../../../MCU/Common/: common.c
  group driver
    ../../../../Driver/src/: gpio.c uart0.c adc.c beeper.c eeprom.c eflash.c gtimer0.c gtimer1.c gtimer2.c lptimer.c lvd.c pwm.c wdt.c
    ../../../../Driver/inc/: adc.h beeper.h eeprom.h eflash.h gpio.h gtimer.h lptimer.h lvd.h pwm.h uart0.h wdt.h
  group app
    ../source/: app.c res_gpio.c
