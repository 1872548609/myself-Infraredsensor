# Keil uVision project UM800Y.uvproj, settings and files
target demo (MCS-51)
  device: R8051XC2 CAST, Inc.
  cpu: IRAM(0-0xFF) CLOCK(24000000)  MOD517DP MDU_R515
  output: um800y +hex
  c flags: Optimize=8
  c include: ..\..\..\..\..\MCU\Common;..\..\..\..\..\MCU\Device;..\..\..\..\..\Driver\inc;..\..\..\..\..\Driver\src
  link misc: REMOVEUNUSED
  group system
    ../../../../../MCU/Device/: STARTUP.A51 system_um800y.c
  group common
    ../../../../../MCU/Common/: common.c
  group driver
    ../../../../../Driver/src/: can_tx.c uart0.c
  group app
    ../source/: app.c main.c
